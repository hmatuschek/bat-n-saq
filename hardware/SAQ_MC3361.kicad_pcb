# Repository hmatuschek/bat-n-saq

File README.md:

# Bat-n-SAQ -- Ein Feldermausdetektor und SAQ-empfänger

Versuch eines Bausatzes für Schüler und Studentengruppen von [Y09](https://www.darc.de/der-club/distrikte/y/ortsverbaende/09/) und [Y07](https://www.darc.de/der-club/distrikte/y/ortsverbaende/07/).

Der Fledermausdetektorbausatz von [Franzis](https://www.franzis.de/maker/bausaetze/fledermausdetektor-zum-selberbauen-bausatz) eignet sich auch hervorragend als [Empfänger](https://www.youtube.com/watch?v=Cch6r8CrXTE) für den VLF Sender [SAQ](https://alexander.n.se/die-radiostation-saq-grimeton/?lang=de). Leider ist der darin enthaltene AM/FM Empfängerbaustein [CD2003](http://www.ak-modul-bus.de/stat/am_fm_empfaenger_cd2003,pd950!0,,CD2003.html) wenn überhaupt, nur noch als SMD Bauelement zu bekommen. Dies macht den Aufbau für Schüler und Studenen schwierig. 

Hier versuchen wir ein kleines Bausatzprojekt für einen gleichwertigen Empfänger/Fledermausdetektor. Dieser sollte mit absoluten Standardbauteilen auskommen und keine SMD Bauelemente verwenden. Alle Elemente sollten direkt auf die Platine gelötet werden und auch das "Gehäuse" sollte aus Platinenmaterial bestehen.

## Todo
 - [ ] [Prototyp](https://github.com/hmatuschek/bat-n-saq/raw/master/hardware/SAQ_scm.pdf) auf Lochraster aufbauen.
 - [ ] Prototyp als Fledermausdetektor testen.
 - [ ] Prototyp als Empfänger testen.
 - [ ] Ggf., HF-Frontend überarbeiten.
 - [ ] Rev.1 Platinen für Schaltung und Gehäuse.
 - [ ] Probeaufbau mit Schülern.
 - [ ] Bausätze zusammenstellen.
 - [ ] Baumappe schreiben.

## Bill of Material
| Element(e) | Wert/Typ |  Reichelt  | Conrad | Preis (10) |
| ---------- | -------- | ---------- | ------ | ---------- |
| R8         | 12 | METALL 12,0 | -- | 0,049€ |
| R9 R10     | 22 | METALL 22,0 | -- | 0,049€ |
| R7         | 1k | METALL 1,00K | -- | 0,049€ |
| R1         | 10k | METALL 10,0K | -- | 0,049€ |
| R4         | 12k | METALL 12,0K | -- | 0,049€ |
| R6         | 22k | METALL 22,0K | -- | 0,049€ |
| R2 R5      | 39k | METALL 39,0K | -- | 0,049€ |
| R3         | 560k | METALL 560K | -- | 0,049€ |
| RV2        | 50k Lin | RK09K113-LIN50K | -- | 0,99€ |
| RV1        | 100k Lin | RK09K113-LIN100K | -- | 0,99€ |
| C1         | 680p NP0 | NPO-2,5 680P | -- | 0,10€ |
| C2 C4 C5 C8 C9 C10 | 10n | Z5U-2,5 10N| -- | 0,05€ |
| C12 C7     | 47n | Z5U-2,5 47N | -- | 0,07€ |
| C11 C14    | 10u Elko | RAD 10/35| -- | 0,02€ |
| C3 C13 C6  | 220u Elko | RND 150ECR AY | -- | 0,06€ |
| D1 D2      | BAT85 | BAT 85 | -- | 0,08€ |
| Q1         | 2N3904 | 2N 3904| -- | 0,04€ |
| U1         | LM555 | NE555 DIP | -- | 0,17€ |
| U2         | LM386 | LM386 DIP | -- | 0,22€ |
| SW1        | SPDT | -- | 1570488 | 0,71€ |
| J1         | Schraub-Terminal  | RND 205-00012 | -- | 0,25€ |
| J3         | Stereo Klinke mit Schalter | EBS 35 | -- | 0,29€ |
| --         | Ultraschallempfänger | -- | 507764 | 2.61€ | 
| --         | 9V Clip | CLIP 9V | -- | 0,29€ |
| --         | Paltienen | -- | -- | ???€ |
| Summe:     | -- | -- | -- | 7,97€ + X |

## KiCad design hardware/SAQ_MC3361.kicad_pcb

Parts:
C1: 680p*; C_Disc_D3.0mm_W2.0mm_P2.50mm
C2, C4, C10: 10n; C_Disc_D3.0mm_W2.0mm_P2.50mm
C3, C6, C13: 220u; CP_Radial_D6.3mm_P2.50mm
C5, C9: 10n; C_Disc_D4.3mm_W1.9mm_P5.00mm
C7: 47n; C_Disc_D4.3mm_W1.9mm_P5.00mm
C8: 1n; C_Disc_D3.0mm_W2.0mm_P2.50mm
C11, C14: 10u; CP_Radial_D6.3mm_P2.50mm
C12: 47n; C_Disc_D3.0mm_W2.0mm_P2.50mm
J1: 100k; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J2: 9V; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J3: 47k; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J4: Sense; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J5: SP; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
Q1: 2N3904; TO-92_Inline_Wide
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R2: 6.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 560k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4: 12k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R6: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8, R9: 12; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
U1: LM555; DIP-8_W7.62mm_LongPads
U2: LM386; DIP-8_W7.62mm_LongPads
U3: MC3361; DIP-16_W7.62mm_LongPads

Connections:
GND: C1.1, C3.2, C6.2, C7.1, C8.2, C10.1, C12.1, J2.1, J3.3, J4.1, J5.1, Q1.1 (E), R6.1, U1.1 (GND), U2.2 (-), U2.4 (GND), U3.15
unnamed: C1.2, J1.3, U1.2 (TR), U1.6 (THR)
unnamed: C2.1, Q1.2 (B), R3.2
unnamed: C2.2, J4.2
unnamed: C4.1, U3.16
unnamed: C4.2, Q1.3 (C), R3.1, R4.2
unnamed: C5.1, R5.2, R6.2
unnamed: C5.2, U3.1
unnamed: C8.1, U3.2
unnamed: C9.1, J3.1
unnamed: C9.2, U3.3
unnamed: C10.2, J3.2, U2.3 (+)
unnamed: C11.1, R7.1
unnamed: C11.2, U2.8 (GAIN)
unnamed: C12.2, R8.2
unnamed: C13.1, R8.1, U2.5
unnamed: C13.2, R9.2
unnamed: C14.2, U2.7 (BYPASS)
unnamed: J1.1, J1.2, R1.2
unnamed: J5.2, R9.1
unnamed: R1.1, R2.2, U1.7 (DIS)
unnamed: R7.2, U2.1 (GAIN)
OSC: R5.1, U1.3 (Q)
VCC: C3.1, C6.1, C7.2, C14.1, J2.2, R2.1, R4.1, U1.8 (VCC), U2.6 (V+), U3.4

Board: 2 copper layers, 32 parts (0 on the bottom side), 24 nets.

## KiCad design hardware/SAQ.kicad_pcb

Parts:
C1: 680p*; C_Disc_D3.0mm_W2.0mm_P2.50mm
C2, C4, C5, C8, C10: 10n; C_Disc_D3.0mm_W2.0mm_P2.50mm
C3, C6, C13: 220u; CP_Radial_D6.3mm_P2.50mm
C7: 47n; C_Disc_D4.3mm_W1.9mm_P5.00mm
C9: 10n; C_Disc_D4.3mm_W1.9mm_P5.00mm
C11, C14: 10u; CP_Radial_D6.3mm_P2.50mm
C12: 47n; C_Disc_D3.0mm_W2.0mm_P2.50mm
D1, D2: BAT85; D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: Sense; TerminalBlock_RND_205-00013_1x03_P5.00mm_Horizontal
J2: 9V; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J3: out; Jack_3.5mm_Ledino_KB3SPRS_Horizontal
J4: SP; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
Q1: 2N3904; TO-92_Inline_Wide
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R2: 6.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 560k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R4: 12k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5: 39k; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
R6: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R8: 12; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R9, R10: 22; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
RV1: 100k; Potentiometer_Alps_RK09K_Single_Vertical
RV2: 47k; Potentiometer_Alps_RK09K_Single_Vertical
SW1: SW_SPDT; SW_Slide_1P2T_CK_OS102011MS2Q
U1: LM555; DIP-8_W7.62mm_LongPads
U2: LM386; DIP-8_W7.62mm_LongPads

Connections:
GND: C1.1, C3.2, C6.2, C7.1, C8.1, C10.1, C12.1, C14.2, D1.2 (A), H1.1, H2.1, H3.1, H4.1, J1.1, J2.1, J3.G, J4.1, Q1.1 (E), R6.2, RV2.3, U1.1 (GND), U2.2 (-), U2.4 (GND)
unnamed: C1.2, RV1.2, RV1.3, U1.2 (TR), U1.6 (THR)
unnamed: C2.1, Q1.2 (B), R3.2
unnamed: C2.2, J1.2, J1.3
unnamed: C4.1, C5.2, D1.1 (K), D2.2 (A)
unnamed: C4.2, Q1.3 (C), R3.1, R4.2
unnamed: C5.1, R5.1
unnamed: C8.2, C9.1, D2.1 (K), R6.1
unnamed: C9.2, RV2.1
unnamed: C10.2, RV2.2, U2.3 (+)
unnamed: C11.1, R7.1
unnamed: C11.2, U2.8 (GAIN)
unnamed: C12.2, R8.2
unnamed: C13.1, R8.1, U2.5
unnamed: C13.2, R9.2, R10.2
unnamed: C14.1, U2.7 (BYPASS)
unnamed: J2.2, SW1.2 (B)
unnamed: J3.S, R9.1
unnamed: J3.SN, J3.TN, J4.2
unnamed: J3.T, R10.1
unnamed: R1.1, R2.2, U1.7 (DIS)
unnamed: R1.2, RV1.1
unnamed: R7.2, U2.1 (GAIN)
OSC: R5.2, U1.3 (Q)
VCC: C3.1, C6.1, C7.2, R2.1, R4.1, SW1.1 (A), U1.8 (VCC), U2.6 (V+)

Board: 2 copper layers, 61.0 x 43.2 mm, 40 parts (0 on the bottom side), 25 nets.

## Commit log

2019-11-11 Initial.
2019-11-11 Fixed LM555 circuit & Caps.
2019-11-11 Added SCM print.
2019-11-11 Fixed PCB.
2019-11-11 Added prototype circuit/board
2019-11-12 Fixed prototype.
2019-11-13 backup
2019-11-18 Added MC3361 variant.
2019-11-18 Added CW bandpass

Notices in the files:
hardware/SAQ.kicad_pcb:
(c) 2019
